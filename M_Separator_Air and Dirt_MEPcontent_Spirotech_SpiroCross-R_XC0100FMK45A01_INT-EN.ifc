Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross-R_XC0100FMK45A01_INT-EN.ifc
Time: 2025-08-05T18:33:06+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (4)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_2118821_1
Port_2118821_2
Port_2118821_3
Port_2118821_4

# IfcValve: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross-R_DN65-100 With Magnet_INT-EN:XC0100FMK45A01, M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross-R_DN65-100 With Magnet_INT-EN:XC0100FMK45A01:2118821
In: F00
Type - Material: Color RAL 1003, Color RGB 040-040-040, Color RGB 128-128-128, Color RGB 198-000-000, Color RGB 168-128-048
Type - Other - Category: Pipe Accessories; Base Flange: 12 mm; Base Flange Diameter: 114.3 mm; Base Flange Radius: 57.2 mm; Bottom Offset: 22.9 mm; Chamfer Radius: 43.8 mm; Cone Flange: 20 mm; Cone Flange Radius Bottom: 71 mm; Cone Flange Radius Top: 57.2 mm; Connection Diameter: 100 mm; DN: 100 mm; Family Name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross-R_DN65-100 With Magnet_INT-EN; Flange Body: 17 mm; Flange Body Radius: 107 mm; Flange Gasket: 3 mm; Flange Gasket Radius: 79 mm; Inner Diameter Ring: 6 mm; Middle-Left Value 2: 340 mm; Middle-Left Value 3: 230 mm; OD: 114.3 mm; Outer Diameter Bracket: 26 mm; Radius 1: 60 mm; Rings Offset 1: 195 mm; Rings Offset 2: 0 mm; Service Space Depth: 222.4 mm; Top Offset: 0 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - D: 219 mm; Depth: 214 mm; H: 1275.4 mm; h1: 460 mm; h2: 325.5 mm; h6: 499 mm; h7: 714 mm; h8: 230 mm; Height: 790 mm; L: 654 mm; Left Offset: 514 mm; LF: 744 mm; Right Offset: 230 mm; Use Nominal Diameter: yes; Width: 421 mm
Type - Identity Data - Article Description: Low loss header with air- and dirt separator - Steel - Flange DN100 - Magnet; Article Type: XC0100FMK45A01; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Low loss header with air- and dirt separator - Steel - Flange DN100 - Magnet; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 12.30; GLN: 8717811000007; GTIN: 8717811061954; Manufacturer: Spirotech; Manufacturer Art. No.: XC0100FMK45A01; Manufacturer URL: https://www.spirotech.com/8717811061954; MEPcontent Class: SEPARATOR_AIR_AND_DIRT; Model: XC0100FMK45A01; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: XC0100FMK45A01; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0 m3/s; Nominal Flow Rate: 0.047 m3/s; Pressure Stage: 6; Volume: 0.045 m3; Weight: 64 kg
Type - Visibility - Back Clearance: 0 mm; Bottom Clearance: 527.9 mm; Front Clearance: 0 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: XC0100FMK45A01; sets with these values: 2
Other - Connector Left Offset: 514 mm; Connector Right Offset: 230 mm; Family: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross-R_DN65-100 With Magnet_INT-EN; Family and Type: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross-R_DN65-100 With Magnet_INT-EN: XC0100FMK45A01; Middle-Left Value 1: 462 mm; Middle-Right Value: 178 mm; Type: XC0100FMK45A01; Type Id: 2118805
Constraints - Elevation from Level: 0 mm
Dimensions - Area: 1.51881 m2; Maximum Size: 100 mm; Minimum Size: 100 mm; Volume: 0.0591076 m3
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s; Flow In 2: 0 m3/s
Phasing - Phase Created: 3. New Construction
Visibility - Counter Flange: no; Counter Flange Safe: no; Flange: yes; Left Clearance: 303.5 mm; Right Clearance: 19.5 mm; Service Space: no; Top Clearance: 0 mm; Top Clearance Safe: 82.5 mm
Insulation - Insulation Thickness: 0 mm
