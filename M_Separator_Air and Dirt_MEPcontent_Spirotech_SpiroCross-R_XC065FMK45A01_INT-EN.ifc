Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross-R_XC065FMK45A01_INT-EN.ifc
Time: 2025-08-05T18:33:04+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (4)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_2118820_1
Port_2118820_2
Port_2118820_3
Port_2118820_4

# IfcValve: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross-R_DN65-100 With Magnet_INT-EN:XC065FMK45A01, M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross-R_DN65-100 With Magnet_INT-EN:XC065FMK45A01:2118820
In: F00
Type - Material: Color RAL 1003, Color RGB 040-040-040, Color RGB 128-128-128, Color RGB 198-000-000, Color RGB 168-128-048
Type - Other - Category: Pipe Accessories; Base Flange: 8 mm; Base Flange Diameter: 76.1 mm; Base Flange Radius: 38.05 mm; Bottom Offset: 0 mm; Chamfer Radius: 31.8 mm; Cone Flange: 17 mm; Cone Flange Radius Bottom: 49 mm; Cone Flange Radius Top: 38.05 mm; Connection Diameter: 65 mm; DN: 65 mm; Family Name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross-R_DN65-100 With Magnet_INT-EN; Flange Body: 15 mm; Flange Body Radius: 92.5 mm; Flange Gasket: 3 mm; Flange Gasket Radius: 61 mm; Inner Diameter Ring: 6 mm; Middle-Left Value 2: 137 mm; Middle-Left Value 3: 196 mm; OD: 76.1 mm; Outer Diameter Bracket: 26 mm; Radius 1: 55 mm; Rings Offset 1: 135 mm; Rings Offset 2: 6 mm; Service Space Depth: 185 mm; Top Offset: 1.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - D: 159 mm; Depth: 185 mm; H: 937.4 mm; h1: 305 mm; h2: 246.1 mm; h6: 236 mm; h7: 451 mm; h8: 195 mm; Height: 790 mm; L: 386 mm; Left Offset: 294 mm; LF: 462 mm; Right Offset: 168 mm; Use Nominal Diameter: yes; Width: 200 mm
Type - Identity Data - Article Description: Low loss header with air- and dirt separator - Steel - Flange DN65 - Magnet; Article Type: XC065FMK45A01; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Low loss header with air- and dirt separator - Steel - Flange DN65 - Magnet; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 12.30; GLN: 8717811000007; GTIN: 8717811061930; Manufacturer: Spirotech; Manufacturer Art. No.: XC065FMK45A01; Manufacturer URL: https://www.spirotech.com/8717811061930; MEPcontent Class: SEPARATOR_AIR_AND_DIRT; Model: XC065FMK45A01; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: XC065FMK45A01; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0 m3/s; Nominal Flow Rate: 0.02 m3/s; Pressure Stage: 6; Volume: 0.016 m3; Weight: 31 kg
Type - Visibility - Back Clearance: 0 mm; Bottom Clearance: 269.3 mm; Front Clearance: 0 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: XC065FMK45A01; sets with these values: 2
Other - Connector Left Offset: 294 mm; Connector Right Offset: 168 mm; Family: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross-R_DN65-100 With Magnet_INT-EN; Family and Type: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross-R_DN65-100 With Magnet_INT-EN: XC065FMK45A01; Middle-Left Value 1: 251 mm; Middle-Right Value: 125 mm; Type: XC065FMK45A01; Type Id: 2118803
Constraints - Elevation from Level: 0 mm
Dimensions - Area: 0.772843 m2; Maximum Size: 65 mm; Minimum Size: 65 mm; Volume: 0.0200674 m3
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s; Flow In 2: 0 m3/s
Phasing - Phase Created: 3. New Construction
Visibility - Counter Flange: no; Counter Flange Safe: no; Flange: yes; Left Clearance: 194 mm; Right Clearance: 68 mm; Service Space: no; Top Clearance: 0 mm; Top Clearance Safe: 3.1 mm
Insulation - Insulation Thickness: 0 mm
